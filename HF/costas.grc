options:
  parameters:
    generate_options: qt_gui
    id: fmvevo
    output_language: python
    title: FM vevo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 19e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kokimester/digitalis_jelfeldolgozas/HF/fromcostas.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/kokimester/digitalis_jelfeldolgozas/HF/tocostas.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.06'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Without costas"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Costas loop"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"PLL written in C"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_file_source_1, '0', digital_costas_loop_cc_0, '0']
- [blocks_file_source_1, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
